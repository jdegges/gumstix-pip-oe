# goliath image

require gumstix-basic-image.bb

IMAGE_INSTALL += " \
    socat \
    "


