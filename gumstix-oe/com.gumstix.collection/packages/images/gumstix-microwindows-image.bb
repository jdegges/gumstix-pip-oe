# basic gumstix image + microwindows

require gumstix-basic-image.bb

IMAGE_INSTALL += " \
    microwindows-snapshot \
    nxlib \
    "


